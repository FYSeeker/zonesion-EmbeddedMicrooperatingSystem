<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>serial-shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\apps\serial-shell\serial-shell.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\apps\shell\shell.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\dev\nullradio.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\aes-128.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ccm-star.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\strncasecmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>ip</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\dhcpc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\ip64-addr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\psock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\resolv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\simple-udp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\slipdev.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\tcp-socket.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\tcpip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\udp-socket.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-nameserver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-packetqueue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-split.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-udp-packet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uiplib.c</name>
        </file>
      </group>
      <group>
        <name>ipv4</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uaodv-rt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uaodv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-fw-drv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-fw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-neighbor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-over-mesh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip_arp.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\dsc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\subprocess.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>cpu</name>
    <group>
      <name>arm</name>
      <group>
        <name>stm32f407</name>
        <group>
          <name>cmsis</name>
        </group>
        <group>
          <name>fwlib</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\misc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_des.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_tdes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dbgmcu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dcmi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma2d.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_exti.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash_ramfunc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_fmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_md5.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_sha1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_ltdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sai.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_syscfg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_wwdg.c</name>
          </file>
        </group>
        <group>
          <name>startup</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\startup\startup_stm32f40xx.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\startup\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\clock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\IIC3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\rtimer-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\usart6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\watchdog.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\..\app\autoapps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\helloworld.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\SysUI\sys_ui.c</name>
      </file>
    </group>
    <group>
      <name>commom</name>
      <group>
        <name>dev</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\BatteryVoltage.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\dm9051_stm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\drive_key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\drive_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\htu21d.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\ili93xx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\onboard_sensors.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\relay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\w25qxx.c</name>
        </file>
      </group>
      <group>
        <name>key</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\key\key.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>ucGUI</name>
      <group>
        <name>AntiAlias</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAArc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAChar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAChar2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAChar4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAACircle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAALib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAALine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAPoly.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\AntiAlias\GUIAAPolyOut.c</name>
        </file>
      </group>
      <group>
        <name>Config</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\Config\GUI_X.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\Config\GUIConf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\Config\LCDConf.h</name>
        </file>
      </group>
      <group>
        <name>ConvertColor</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP111.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP222.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP233.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP323.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP332.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP444_12.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP444_12_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP444_16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP555.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP556.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP565.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP655.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP8666.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDP8666_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM233.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM323.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM332.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM444_12.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM444_16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM555.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM556.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM565.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertColor\LCDPM655.c</name>
        </file>
      </group>
      <group>
        <name>ConvertMono</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertMono\LCDP0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertMono\LCDP2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\ConvertMono\LCDP4.c</name>
        </file>
      </group>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI2DLib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__AddSpaceHex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__CalcTextRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__DivideRound.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__DivideRound32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__GetFontSizeY.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__GetNumChars.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__HandleEOLine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__IntersectRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__IntersectRects.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__memset.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__memset16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__Read.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__ReduceRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__SetText.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__strcmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__strlen.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI__Wrap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddBin.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddDec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddDecMin.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddDecShift.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddHex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_AddKeyMsgHook.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_ALLOC_AllocInit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_ALLOC_AllocZero.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_BMP.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_BMP_Serialize.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CalcColorDist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_ClearRectEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Color2VisColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowLI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowLPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowMI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowMPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowSI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorArrowSPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossLI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossLPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossMI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossMPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossSI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorCrossSPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorHeaderM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorHeaderMI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorHeaderMPx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorPal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_CursorPalI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispBin.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispCEOL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispChar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispChars.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispHex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispString.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringAt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringAtCEOL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringHCenter.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringInRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringInRectEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringInRectMax.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DispStringLen.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawBitmap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawBitmapEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawBitmapExp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawBitmapMag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawFocusRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawGraph.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawHLine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawPie.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawPixel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawPolyline.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawRectEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_DrawVLine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_ErrorOut.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Exec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_FillPolygon.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_FillRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_FillRectEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetBitmapPixelColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetBitmapPixelIndex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetClientRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetDispPos.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetFont.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetFontInfo.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetFontSizeY.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetLineStyle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetStringDistX.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetTextAlign.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetTextExtend.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetTextMode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetVersionString.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_GetYSizeOfFont.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Goto.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_InitLUT.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_InvertRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_IsInFont.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Log.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_MergeRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_MOUSE.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_MOUSE_DriverPS2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_MoveRect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_OnKey.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Pen.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_PID.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_RectsIntersect.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SaveContext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SelectLayer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SelectLCD.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetColorIndex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetDecChar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetDefault.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetDrawMode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetFont.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetLBorder.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetLineStyle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetLUTColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetLUTColorEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetLUTEntry.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetOrg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetPixelIndex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetTextAlign.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetTextMode.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SetTextStyle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SIF.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_SIF_Prop.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_TOUCH.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_TOUCH_DriverAnalog.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_TOUCH_StoreState.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_TOUCH_StoreUnstable.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_UC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_UC_DispString.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_UC_EncodeNone.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_UC_EncodeUTF8.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_WaitEvent.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_WaitKey.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUI_Warn.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIAlloc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIArc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIChar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICharLine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICharM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICharP.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICirc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIColor2Index.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICore.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUICurs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIEncJS.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIIndex2Color.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIPolyE.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIPolyM.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIPolyR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIRealloc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIStream.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUITask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUITime.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUITimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIUC0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIVal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\GUIValf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_API.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_DrawBitmap_565.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_DrawBitmap_M565.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_DrawVLine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_GetColorIndex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_GetEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_GetNumDisplays.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_GetPixelColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_Index2ColorEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_L0_Generic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_Mirror.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_MixColors256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_Rotate180.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_RotateCCW.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_RotateCW.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_SelectLCD.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_SetAPI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_SetClipRectEx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCD_UpdateColorIndices.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDAA.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDColor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDGetP.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDInfo.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDInfo0.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDInfo1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDL0Delta.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDL0Mag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDP1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDP565_Index2Color.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDPM565_Index2Color.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDRLE4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Core\LCDRLE8.c</name>
        </file>
      </group>
      <group>
        <name>Font</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F08_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F08_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F10_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F10_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F10S_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F10S_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13H_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13H_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13HB_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F13HB_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16_1HK.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16_HK.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F16B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F24_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F24_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F24B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F24B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F32_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F32_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F32B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F32B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F4x6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F6x8.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x10_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x12_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x13_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x13_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x15B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x15B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\F8x8.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FComic18B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FComic18B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FComic24B_1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FComic24B_ASCII.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD24x32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD36x48.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD48.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD48x64.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD60x80.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD64.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\Font\FD80.c</name>
        </file>
      </group>
      <group>
        <name>LCDDriver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\ucGUI\GUI\LCDDriver\LCDDummy.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\app\readme\readme.txt</name>
  </file>
</project>


